# Keil uVision project Blinky.uvprojx, settings and files
target STM32L100C-Discovery (6140000::V6.14::ARMCLANG)
  device: STM32L100RCTx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.2.0.0-dev0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSI_VALUE=16000000U
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group App
    ./: Blinky.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L100RCTx/STCubeGenerated/Src/: main.c stm32l1xx_it.c
    ./RTE/Device/STM32L100RCTx/STCubeGenerated/Inc/: stm32l1xx_it.h
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, Device:STM32Cube HAL 1.4.1, CMSIS Driver:VIO:Board 1.0.0
