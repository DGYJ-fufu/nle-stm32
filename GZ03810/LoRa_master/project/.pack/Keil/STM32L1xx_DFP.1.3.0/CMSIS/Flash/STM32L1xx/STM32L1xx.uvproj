# Keil uVision project STM32L1xx.uvproj, settings and files
target STM32L1xx_128 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: STM32L1xx_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEMORY STM32L1xx_128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STM32L1xx_256 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: STM32L1xx_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEMORY STM32L1xx_256
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32L1xx_384 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: STM32L1xx_384
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEMORY STM32L1xx_384
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32L1xx_512 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: STM32L1xx_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEMORY STM32L1xx_512
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32L1xx_128_EEPROM (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: STM32L1xx_128_EEPROM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_EEPROM STM32L1xx_128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32L1xx_256_EEPROM (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: STM32L1xx_256_EEPROM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_EEPROM STM32L1xx_256
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32L1xx_384_EEPROM (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: STM32L1xx_384_EEPROM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_EEPROM STM32L1xx_384
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32L1xx_512_EEPROM (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: STM32L1xx_512_EEPROM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_EEPROM STM32L1xx_512
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32L1xx_128_OPT (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: STM32L1xx_128_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_OPTION STM32L1xx_128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32L1xx_256_OPT (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: STM32L1xx_256_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_OPTION STM32L1xx_256
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32L1xx_384_OPT (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: STM32L1xx_384_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_OPTION STM32L1xx_384
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32L1xx_512_OPT (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: STM32L1xx_512_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_OPTION STM32L1xx_512
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
